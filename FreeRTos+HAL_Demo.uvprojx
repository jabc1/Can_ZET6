# Keil uVision project FreeRTos+HAL_Demo.uvprojx, settings and files
target FreeRTos+HAL_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HAL_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE,USE_HAL_DRIVER
  c include: .\App;.\CMSIS;.\Core;.\HAL_lib\STM32F1xx_HAL_Driver\Inc;.\HAL_lib\STM32F1xx_HAL_Driver\Inc\Legacy;.\User;.\FreeRTos\include;.\FreeRTos\inc;.\FreeRTos;.\Task;.\App\LCD;.\Can;.\Can\SysLib\inc;.\MyFIFO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ./Core/: core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h cmsis_armcc.h
  group HAL_lib
    ./HAL_lib/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group FreeRTos
    ./FreeRTos/src/: croutine.c heap_4.c list.c port.c queue.c tasks.c timers.c
    ./FreeRTos/: FreeRTOSConfig.h
    ./FreeRTos/inc/: portmacro.h
  group MyFIFO
    ./MyFIFO/: myfifo.c myfifo.h
  group CMSIS
    ./CMSIS/: startup_stm32f103xe.s stm32f1xx.h system_stm32f1xx.h re_def.h
  group Can
    ./Can/: CanRx.c CanRx.h CanTx.c CanTx.h SysCan.c SysCan.h NewCanTx.c NewCanTx.h
  group CanFIFO
    ./Can/SysLib/src/: CRC.C Fifo.c NuboLib.c
    ./Can/SysLib/inc/: CRC.h Fifo.h NbType.h NuboLib.h
  group User
    ./User/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_conf.h stm32f1xx_it.h
  group App
    ./App/: gpio.c gpio.h sys.c sys.h myusart.c myusart.h mytiem.c mytiem.h mykey.c mykey.h ReceiveFunction.c
  group Task
    ./Task/: MyTask.c MyTask.h
  group ReadMe
    ./: ReadMe.txt
